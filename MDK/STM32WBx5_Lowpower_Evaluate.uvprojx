# Keil uVision project STM32WBx5_Lowpower_Evaluate.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32WB35CEUxA STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: STM32WBx5_Lowpower_Evaluate +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STM32WBXX_NUCLEO,USE_HAL_DRIVER,STM32WB35xx
  c include: ..\Application\Inc;..\STM32_WPAN\App;..\STM32WBx5_HAL_Drivers\STM32WBxx_HAL_Driver\Inc;..\STM32WBx5_HAL_Drivers\STM32WBxx_HAL_Driver\Inc\Legacy;..\Middlewares\ST\STM32_WPAN;..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread;..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\tl;..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\shci;..\Middlewares\ST\STM32_WPAN\utilities;..\Utilities\lpm\tiny_lpm;..\Utilities\sequencer;..\Middlewares\ST\STM32_WPAN\ble;..\Middlewares\ST\STM32_WPAN\ble\core\template;..\Middlewares\ST\STM32_WPAN\ble\core;..\STM32WBx5_HAL_Drivers\CMSIS\Device\ST\STM32WBxx\Include;..\STM32WBx5_HAL_Drivers\CMSIS\Include;..\BSP;..\Hardware\nand_flash\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\STM32WBx5_HAL_Drivers\CMSIS\Device\ST\STM32WBxx\Source\Templates\arm\linker\stm32wb35xx_flash_cm4.sct
  group Startup
    ../STM32WBx5_HAL_Drivers/CMSIS/Device/ST/STM32WBxx/Source/Templates/arm/: startup_stm32wb35xx_cm4.s
  group User
    ../Application/Src/: app_debug.c app_entry.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c
  group User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c dis_app.c hrs_app.c
  group STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Driver/BSP
    ../BSP/: stm32wbxx_nucleo.c stm32wbxx_cml_qspi.c stm32wbxx_cml_dma.c
  group Driver/Hardware
    ../Hardware/nand_flash/Src/: nand_flash.c
  group CMSIS
    ../STM32WBx5_HAL_Drivers/CMSIS/Device/ST/STM32WBxx/Source/Templates/: system_stm32wbxx.c
  group HAL_Drivers
    ../STM32WBx5_HAL_Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_comp.c stm32wbxx_hal_cortex.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_cryp.c stm32wbxx_hal_cryp_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_irda.c stm32wbxx_hal_iwdg.c stm32wbxx_hal_lcd.c stm32wbxx_hal_lptim.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pka.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_qspi.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rng.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_usart.c stm32wbxx_hal_usart_ex.c stm32wbxx_hal_wwdg.c
  group Middleware/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl_if.c shci_tl_if.c tl_mbox.c hci_tl.c shci_tl.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c dis.c hrs.c
    ../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
software components: CMSIS:CORE 5.5.0
